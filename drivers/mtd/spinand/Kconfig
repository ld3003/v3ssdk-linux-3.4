## drivers/mtd/spinand/Kconfig
```kconfig
#
# Input device configuration
#

config SPI_NAND
	tristate "SPI Nand Flash"
	default y
	help
	  If unsure, say Y.
```
